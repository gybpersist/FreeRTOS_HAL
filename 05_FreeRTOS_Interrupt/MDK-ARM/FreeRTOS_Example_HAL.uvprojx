# Keil uVision project FreeRTOS_Example_HAL.uvprojx, settings and files
target FreeRTOS_Example_HAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: FreeRTOS_Example_HAL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Development/App;../Development/Com;../Development/Dri;../Development/Int;../Development/Mid;../Development/Mid/FreeRTOS;../Development/Mid/FreeRTOS/include;../Development/Mid/FreeRTOS/portable
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Development/App
    ../Development/App/: App_FreeRTOS.c App_FreeRTOS.h
  group Development/Com
    ../Development/Com/: Com_Debug.c Com_Debug.h
  group Development/Int
    ../Development/Int/: Int_Key.c Int_Key.h Int_LED.c Int_LED.h
  group Development/Mid/FreeRTOS
    ../Development/Mid/FreeRTOS/: croutine.c event_groups.c FreeRTOSConfig.h list.c queue.c stream_buffer.c tasks.c timers.c
  group Development/Mid/FreeRTOS/portable
    ../Development/Mid/FreeRTOS/portable/: heap_4.c port.c
software components: CMSIS:CORE 4.3.0
